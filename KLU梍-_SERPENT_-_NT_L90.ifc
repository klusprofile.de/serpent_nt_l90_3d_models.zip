Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: a2e491e8-677d-4bf0-8be0-ca6795cbb2f3, NumberOfSaves: 9], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Internal]
File name: Project Number
Time: 2023-11-29T13:33:57+01:00
Written by: ODA SDAI 24.6
Made in: Autodesk Revit 24.2.0.63 (ENU) - IFC 24.1.1.6

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 0; sets with these values: 2
Other - Category: Levels; Family: Level; Family and Type: Level: Circle Head - Project Datum; Type: Circle Head - Project Datum; Type Id: 305
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 0; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle : Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no
Identity Data(Type) - Type Name: Circle Head - Project Datum

# IfcDistributionPort, Port_330428_1
Description: Flow; FlowDirection: SOURCEANDSINK

# IfcFlowTerminal: KLUŚ - SERPENT - NT L90:Silver Anodized - 3000 K - 680 lm, KLUŚ - SERPENT - NT L90:Silver Anodized - 3000 K - 680 lm:330428
In: Level 0
Type - Material: Steel, Aluminum, Silver Anodized, PC - 3000 K
Type - Other - Category: Lighting Fixtures; Color: silver anodized; Control: ON/OFF; Cover: frosted; Dimensions L x W x H: 245 x 245 x 88; Family Name: KLUŚ - SERPENT - NT L90; Lighting direction: down; Material: aluminum; Mounting type: surface mounted; Shape: L
Type - Constraints - Default Elevation: 0 mm
Type - Data - Color rendering index: 90 CRI; Color temperature: 3000 K; Efficiency: 62 lm/W; IP protection rating: IP20; Luminare power: 11 W; Luminous flux of the fixture: 680 lm; MacAdam’s ellipse: 3 SDCM; Protection class: I; Supply voltage: 220-240 V 50/60 Hz
Type - Dimensions - Light Source Symbol Size: 5 mm
Type - Electrical - Loads - Apparent Load: 11 W; Input voltage: 240 V; Power consumption: 11 W; Power factor: 1
Type - General - OmniClassCode: 23.80.70.11.14.11; OmniClassTitle: Downlights; Uniclass2015Code: Pr_70_70_48_24; Uniclass2015Title: Downlights; Uniclass2015Version: Products v1.31
Type - Identity Data - Author: www.archispace.pl; Manufacturer: KLUŚ Sp. z o.o.; Model: NT L90; OmniClass Number: 23.80.70.11.14.11; OmniClass Title: Downlights; Ref No: FNSE101-0130EB; System: SERPENT; Type Name: Silver Anodized - 3000 K - 680 lm; URL: https://klusdesign.eu/en
Type - Photometrics - Color Filter: 16777215; Dimming Lamp Color Temperature Shift: <None>; Efficacy: 148.542 s3*lm/kg/m2; Emit from Rectangle Length: 250 mm; Emit from Rectangle Width: 250 mm; Emit Shape Visible in Rendering: no; Illuminance: 54.8201 lx; Initial Color Temperature: 3000 K; Light Source Definition (family): Rectangle+HemiSpherical; Luminous Flux: 680 lm; Luminous Intensity: 509.296 cd; Total Light Loss Factor: 1; Wattage: 10.7714 W
Type - Materials and Finishes - Body material: Aluminum, Silver Anodized; Diffuser material: PC - 3000 K
Type - Pset_ElementShading - Color: silver anodized
Type - Pset_ManufacturerTypeInformation - Manufacturer: KLUŚ Sp. z o.o.
Pset_DistributionFlowElementCommon - Reference: KLUŚ - SERPENT - NT L90:Silver Anodized - 3000 K - 680 lm; sets with these values: 2
Other - Family: KLUŚ - SERPENT - NT L90; Family and Type: KLUŚ - SERPENT - NT L90: Silver Anodized - 3000 K - 680 lm; Type: Silver Anodized - 3000 K - 680 lm; Type Id: 330321
Model Properties - Connector n: 3
Constraints - Elevation from Level: 93 mm; Host: Reference Plane; Level: Level 0; Schedule Level: Level 0
Construction - Plug left: yes; Plug right: yes; Power cable: yes
Dimensions - Area: 0.142002 m2; Volume: 0.0021338 m3
Electrical - Circuiting - Electrical Data: 220-240 V 50/60 Hz 240 V/1-11 VA
Electrical - Lighting - Calculate Coefficient of Utilization: no
Identity Data - Mark: 13
Phasing - Phase Created: New Construction
